# Repository gerse-ifsp-campus-guarulhos/ShieldEduIfspStm32

File README.md:

# ShieldEduIfspStm32

Licença: GNU GPL 2

Autores: [Pedro Igor Borçatti da Silva](https://github.com/pedro-ibs), Rogerio Daniel Dantas

This program is free software; you can redistribute it and/or
modify it under the terms of the GNU General Public License as
published by the Free Software Foundation; version 2 of the
License.

This program is distributed in the hope that it will be useful,
but WITHOUT ANY WARRANTY; without even the implied warranty of
MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
GNU General Public License for more details.

---

O SHIELD EDU IFSP STM32 é uma placa didática criada para a [blue pill](https://wiki.stm32duino.com/index.php?title=Blue_Pill) de baixo custo, desenvolvida para o ensino de lógica de programação aplicada à robótica e Iot (internet das coisas), cujo principal objetivo é facilitar o ensino de lógica de programação. 

Neste Repositório se encontra todos os arquivos necessários para o **DESENVOLVIMENTO e DOCUMENTAÇÃO** para a **SHIELD EDU IFSP STM32**, esse projeto encontra se em desenvolvimento.

Na pasta [PCB](PCB/) estão os arquivos para fabricação da placa, tanto o [GERBER](PCB/) para fabricação manufaturada. Em [Documentação](Documentação/) temos os arquivos referente as informações e manuais do circuito criadas até o momento, como o  [esquema elétrico](Documentação/ShieldEduIfspStm32.pdf).  Em [circuitoKicad](circuitoKicad/) temos os arkivos edivaves do projeto  (desenvolvido no [kicad EDA 5.0.2](http://www.kicad.org/)) suas dependências (exceto os pacotes 3D da PCB).

# Notas de versão
 * REV160
   * Removido seletor VCOM das saidas modulares (agora apenas 5V exceto SPI).
   * Bluetooth ajustado na PCB (restava trombando com o blue pill).

# Visual aproximado do circuito:

## KiCad design circuitoKicad/ShieldEduIfspSTM32.kicad_pcb

Parts:
C1: 220uF 35V; CP_Elec_8x10.5
C2, C3, C5: 0u1F; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 10uF 25V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 1000uF 6V3; CP_Elec_8x10.5
D1: SS14; D_MELF_Handsoldering
J1: VIM; TerminalBlock_Phoenix_PT-1,5-2-3.5-H_1x02_P3.50mm_Horizontal
J2, J3: I2C; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J4: Bluetooth_UsbSerial; PinSocket_1x04_P2.54mm_Vertical
J5: USART_1B; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J6: SPI; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
J7: ADC; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J8: USB / CAM; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J9: INPUT; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
J10: OUTPUT; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
J11: OUT-MUX; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
JP2: JUMP3; PinSocket_1x03_P2.54mm_Vertical
R2, R4: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R5: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: STM32 blue pill; stm32f103c8t6-module-china
U2: DCDCStepDown; miniDCDC
U3: KF33BDT; TO-252-2

Connections:
/AI0: J7.1, R2.1
/AI1: J7.2, R4.1
/IN1: J9.4; also elsewhere on the board
/IN2: J9.3; also elsewhere on the board
/IN3: J9.2; also elsewhere on the board
/IN4: J9.1; also elsewhere on the board
/OUT1: J10.4; also elsewhere on the board
/OUT2: J10.3; also elsewhere on the board
/OUT3: J10.2; also elsewhere on the board
/OUT4: J10.1; also elsewhere on the board
/OUT_D14: J11.1; also elsewhere on the board
/OUT_D15: J11.2; also elsewhere on the board
/PA1: R4.2, R5.1, U1.6 (PA1); also elsewhere on the board
/PA2: U1.7 (PA2); also elsewhere on the board
/PA3: U1.8 (PA3); also elsewhere on the board
/PA4: U1.9 (PA4); also elsewhere on the board
/PA5: U1.10 (PA5); also elsewhere on the board
/PA6: U1.11 (PA6); also elsewhere on the board
/PA7: U1.12 (PA7); also elsewhere on the board
/PA8: U1.25 (PA8); also elsewhere on the board
/PA9: J4.1, U1.26 (PA9); also elsewhere on the board
/PA10: J4.2, U1.27 (PA10); also elsewhere on the board
/PA11: J8.2, U1.28 (PA11)
/PA12: J8.1, U1.29 (PA12)
/PA15: J6.4, U1.30 (PA15)
/PB0: U1.13 (PB0); also elsewhere on the board
/PB1: U1.14 (PB1); also elsewhere on the board
/PB3: J6.3, U1.31 (PB3); also elsewhere on the board
/PB4: J6.2, U1.32 (PB4); also elsewhere on the board
/PB5: J6.1, U1.33 (PB5); also elsewhere on the board
/PB6: J5.1, U1.34 (PB6)
/PB7: J5.2, U1.35 (PB7)
/PB8: J2.1, J3.1, U1.36 (PB8); also elsewhere on the board
/PB9: J2.2, J3.2, U1.37 (PB9); also elsewhere on the board
/PB10: U1.15 (PB10); also elsewhere on the board
/PB11: U1.16 (PB11); also elsewhere on the board
/PB12: U1.21 (PB12); also elsewhere on the board
/PB13: U1.22 (PB13); also elsewhere on the board
/PB14: U1.23 (PB14); also elsewhere on the board
/PB15: U1.24 (PB15); also elsewhere on the board
/PC13: U1.2 (PC13); also elsewhere on the board
/RST: U1.17 (RESET); also elsewhere on the board
Earth: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, J1.1, J2.4, J3.4, J4.3, J5.4, J6.6, J7.4, J8.4, J9.5, J10.5, J11.4, R3.2, R5.2, U1.19 (GND), U1.20 (GND), U1.39 (GND), U2.2 (GND_IN), U2.3 (GND_OUT), U3.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), J1.2
VCC: C1.1, C2.1, D1.1 (K), J9.6, J10.6, J11.3, U2.1 (VIN); also elsewhere on the board

Notes on the sheet:
CONEXÔES
Alimentação
MCU - Blue Pill ( STM32F103C8 / STM32F103CB )
Saída M2M / GPIO Externa Modular
Periféricos
MUX, IHM (Gráfica e Física), expansão
M2M Interna, Driver de entrada e saída.
ADC 12 Bits TOLERÂNCIA DO PINO 3V3 COM DIVISOR 0V A 30V
Seletor de tensão para saídas modulares
3V3 500mA 1650mW
5V 1A 5W
Há periféricos com o USART1, I2C1, SPI1 e CAN1 que está disponível em diversos pinos para usar outro grupo de pinos que não são padrão é preciso utilizar a função “GPIO_PinRemapConfig” e configurar os pinos respectivos devidamente, Exemplo da função PinRemaP para a USART1: GPIO_PinRemapConfig(GPIO_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
VBAT, C12, C15 estão dedicados para clock (cristal externo) do RTC do ARM

Parts:
AE1: Antenna_Shield; rf SMA 90°-2
JP3: ~E2; jumpHandSolder
JP4: ~E1; jumpHandSolder
JP5: ~E0; jumpHandSolder
R11, R12, R13, R14, R17, R18, R19: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R20, R21: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U4: RFM95W-915S2; HOPERF_RFM9XW_SMD
U5: ESP01
U6: ULN2803A; SOIC-18W_7.5x11.6mm_P1.27mm
U8: M24CXX; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/IN1: R11.2, U6.14 (O5); also elsewhere on the board
/IN2: R12.2, U6.13 (O6); also elsewhere on the board
/IN3: R13.2, U6.12 (O7); also elsewhere on the board
/IN4: R14.2, U6.11 (O8); also elsewhere on the board
/OUT1: U6.18 (O1); also elsewhere on the board
/OUT2: U6.17 (O2); also elsewhere on the board
/OUT3: U6.16 (O3); also elsewhere on the board
/OUT4: U6.15 (O4); also elsewhere on the board
/PA4: U6.8 (I8); also elsewhere on the board
/PA5: U6.7 (I7); also elsewhere on the board
/PA6: U6.6 (I6); also elsewhere on the board
/PA7: U6.5 (I5); also elsewhere on the board
/PA8: U5.6 (CH_PD); also elsewhere on the board
/PA9: U5.4 (RXD); also elsewhere on the board
/PA10: U5.5 (TXD); also elsewhere on the board
/PB0: U6.4 (I4); also elsewhere on the board
/PB1: U6.3 (I3); also elsewhere on the board
/PB3: U4.4 (SCK); also elsewhere on the board
/PB4: U4.2 (MISO); also elsewhere on the board
/PB5: U4.3 (MOSI); also elsewhere on the board
/PB8: R21.2, U8.6 (SCL); also elsewhere on the board
/PB9: R20.2, U8.5 (SDA); also elsewhere on the board
/PB10: U6.2 (I2); also elsewhere on the board
/PB11: U6.1 (I1); also elsewhere on the board
/PB15: U4.5 (NSS); also elsewhere on the board
/RST: U4.6 (RESET), U5.7 (RST); also elsewhere on the board
Earth: AE1.2 (Shield), JP3.1 (A), JP4.1 (A), JP5.1 (A), U4.1 (GND), U4.8 (GND), U4.10 (GND), U5.1 (GND), U6.9 (GND), U8.4 (VSS), U8.7 (~WC); also elsewhere on the board
unnamed: AE1.1 (A), U4.9 (ANT)
unnamed: JP3.2 (B), R17.2, U8.3 (E2)
unnamed: JP4.2 (B), R18.2, U8.2 (E1)
unnamed: JP5.2 (B), R19.2, U8.1 (E0)
VCC: R11.1, R12.1, R13.1, R14.1, U6.10 (COM); also elsewhere on the board

Notes on the sheet:
M2M Interna
Driver de entrada e saída para alta potência
Todos os OUTPUTS chaveiam para GROUD e Suportam 50V/500mA Todos os INPUTS suportam 30V e estão com PULL-PU em VCC, não utilizar sinal de tensão acima de VCC
RCLT é o pino de controle do RFM95W e é diferente do nativo da SPI1 isso garante comunicação em barramento WCLT é o ENABLE do ESP01 e faz trabalho que RCLT
A EEPROM está ligada diretamente no I2C e contém os PULL-UP em SDA e SCL, seu endereço é controlado pelos jumper E0, E1 e E2

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
D5: LED_RGB; LED_WS2812_PLCC6_5.0x5.0mm_P1.6mm
D6, D9: VERDE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7, D10: AMARELO; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D8, D11: VERMELHO; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D12, D13: AZUL; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DS1: 16X2; myLCD16x2
JP7: BZ; jumpHandSolder
R1: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R22, R23, R24, R26, R28, R29, R30, R31, R32, R33, R34, R35: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R25: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R45: X; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 1K; Potentiometer_ACP_CA6-VSMD_Vertical
RV2: 10K; Potentiometer_Alps-RK16-single_largePads
SW1, SW2: SW_PUSH; SW_PUSH_6mm_H4.3mm
SW3: SP6T; SW_PUSH_x2
U9, U10: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm
U11: HS-3461B
U12: ULN2803A; SOIC-18W_7.5x11.6mm_P1.27mm

Connections:
/IHM/A: D6.2 (A), R28.1, U11.11 (a)
/IHM/B: D7.2 (A), R29.1, U11.7 (b)
/IHM/C: D8.2 (A), R30.1, U11.4 (c)
/IHM/D: D9.2 (A), R31.1, U11.2 (d)
/IHM/DPX: D13.2 (A), R35.1, U11.3 (DPX)
/IHM/E: D10.2 (A), R32.1, U11.1 (e)
/IHM/ENBZ: BZ1.2 (+), U12.16 (O3)
/IHM/ENCA1: U11.12 (CA1), U12.11 (O8)
/IHM/ENCA2: U11.9 (CA2), U12.12 (O7)
/IHM/ENCA3: U11.8 (CA3), U12.13 (O6)
/IHM/ENCA4: U11.6 (CA4), U12.14 (O5)
/IHM/ENLED: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), U12.15 (O4)
/IHM/F: D11.2 (A), R33.1, U11.10 (f)
/IHM/G: D12.2 (A), R34.1, U11.5 (g)
/IHM/PD0: R28.2, U9.15 (QA)
/IHM/PD1: R29.2, U9.1 (QB)
/IHM/PD2: DS1.5 (R/W), R30.2, U9.2 (QC)
/IHM/PD3: R31.2, U9.3 (QD)
/IHM/PD4: DS1.14 (D7), R32.2, U9.4 (QE)
/IHM/PD5: DS1.13 (D6), R33.2, U9.5 (QF)
/IHM/PD6: DS1.4 (RS), DS1.12 (D5), R34.2, U9.6 (QG)
/IHM/PD7: DS1.11 (D4), R35.2, U9.7 (QH)
/IHM/PD8: DS1.6 (E), R25.2, U10.15 (QA)
/IHM/PD9: U10.1 (QB), U12.8 (I8)
/IHM/PD10: U10.2 (QC), U12.7 (I7)
/IHM/PD11: U10.3 (QD), U12.6 (I6)
/IHM/PD12: U10.4 (QE), U12.5 (I5)
/IHM/PD13: U10.5 (QF), U12.4 (I4)
/IHM/PD14: U10.6 (QG), U12.2 (I2)
/IHM/PD15: U10.7 (QH), U12.1 (I1)
/IHM/SER: U9.9 (QH'), U10.14 (SER)
/OUT_D14: U12.17 (O2); also elsewhere on the board
/OUT_D15: U12.18 (O1); also elsewhere on the board
/PA1: SW3.2, SW3.5; also elsewhere on the board
/PA2: RV2.2; also elsewhere on the board
/PA3: U12.3 (I3); also elsewhere on the board
/PB1: R24.1; also elsewhere on the board
/PB10: R23.1; also elsewhere on the board
/PB11: R22.1; also elsewhere on the board
/PB12: U9.14 (SER); also elsewhere on the board
/PB13: U9.12 (RCLK), U10.12 (RCLK); also elsewhere on the board
/PB14: U9.11 (SRCLK), U10.11 (SRCLK); also elsewhere on the board
/PC13: SW1.1; also elsewhere on the board
Earth: DS1.1 (VSS), R25.1, R26.2, RV1.3, RV2.1, U9.8 (GND), U9.13 (~OE), U10.8 (GND), U10.13 (~OE), U12.9 (GND); also elsewhere on the board
unnamed: BZ1.1 (-), JP7.2 (B), R45.2
unnamed: D5.4 (BA), R22.2
unnamed: D5.5 (GA), R23.2
unnamed: D5.6 (RA), R24.2
unnamed: DS1.3 (VO), RV1.2
unnamed: DS1.16 (LED-), R26.1
unnamed: R1.1, SW1.2
VCC: U12.10 (COM); also elsewhere on the board

Notes on the sheet:
SHIFT REGISTER (MUX / expansão)
IHM Grafica
IHM Fisica
OUT EXTENDIDA / DRIVER
Todos os OUTPUTS chaveiam para GROUD e Suportam 50V/500mA Todos os INPUTS suportam 30V e estão com PULL-PU em VCC, não utilizar sinal de tensão acima de VCC
As saídas da expansão estão distribuídas comumente a toda interface visual, com exceção das saídas D8,D9, D10, D11, D12 e D13, estas estão dedicadas como ENABLE e cada uma controla um elemento, isso permite a MULTIPLEXAÇÃO/SELEÇÃO do componente a ser usado
R45 e JP7 Existem para delimitar a altura máxima do buzzer. BT2 E BT3 estão comum a saída ADC modular
O LED RGB tem os terminais em comum com as saída modular OUT sendo eles B1, B10 E B11.

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
Board: 2 copper layers, 100.0 x 75.0 mm, 78 parts (6 on the bottom side), 90 nets.

## Commit log

2019-07-25 upload rev 1.5
2019-07-29 REV160
2019-07-29 add notas de versão
2019-07-29 add notas de versão (1.6)
2019-07-29 corrigindo redame
2021-11-09 Update README.md
    https://forum.kicad.info/t/warning-avoid-all-links-to-kicad-pcb-org-use-kicad-org/31521
